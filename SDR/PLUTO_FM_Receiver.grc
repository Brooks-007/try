options:
  parameters:
    generate_options: qt_gui
    id: RTL_SDR_FM
    output_language: python
    title: RTL FM Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '87000000'
    step: 0.1e6
    stop: '108000000'
    value: '100000000'
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '48000'
    deviation: '75000'
    gain: '10'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: tune
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tune
    fftsize: '1024'
    label1: Raw
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5
    fc: '0'
    fftsize: '1024'
    label1: Filterd
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/5/10
    fc: '0'
    fftsize: '1024'
    label1: demodulated
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '8192'
    srate: samp_rate/5/10
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0_0, '0', audio_sink_0, '0']
- [analog_fm_demod_cf_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [analog_fm_demod_cf_0_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', analog_fm_demod_cf_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
